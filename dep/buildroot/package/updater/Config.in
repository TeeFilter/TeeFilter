## dep/buildroot/package/updater/Config.in
```kconfig
config BR2_PACKAGE_UPDATER
    bool "updater"
    help
      The TeeFilter rule updater kernel module.
```
